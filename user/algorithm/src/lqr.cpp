/**
 *******************************************************************************
 * @file      : lqr.cpp
 * @brief     :
 * @history   :
 *  Version     Date            Author          Note
 *  V0.9.0      yyyy-mm-dd      <author>        1. <note>
 *******************************************************************************
 * @attention :
 *******************************************************************************
 *  Copyright (c) 2024 Reborn Team, USTB.
 *  All Rights Reserved.
 *******************************************************************************
 */
 /* Includes ------------------------------------------------------------------*/
#include "lqr.h"

#include "stdint.h"
/* Private macro -------------------------------------------------------------*/
/* Private constants ---------------------------------------------------------*/
/* Private types -------------------------------------------------------------*/
/* Private variables ---------------------------------------------------------*/

//K的三次拟合系数
const float k[12][4] = {
{-2902.318037f, 2621.498655f, -922.320506f, 29.191190f},
{-314.769911f, 278.475561f, -136.512348f, -0.035734f},
{-278.856885f, 282.731840f, -99.396916f, -1.582426f},
{317.558581f, -171.661715f, 7.641877f, -15.546298f},
{-332.042363f, 524.089152f, -284.235775f, 61.615392f},
{-445.898731f, 423.469796f, -151.836796f, 24.598093f},
{6101.030137f, -4236.384414f, 741.853610f, 38.360655f},
{68.790690f, 81.519661f, -103.138350f, 35.274906f},
{126.821118f, 67.004999f, -110.382312f, 32.102811f},
{-1765.997321f, 1590.197228f, -525.156068f, 74.229016f},
{3469.306332f, -3123.519135f, 971.922253f, -19.324111f},
{1914.220925f, -1625.771473f, 470.692843f, -25.388500f}
};

/* External variables --------------------------------------------------------*/
/* Private function prototypes -----------------------------------------------*/

void Lqr::Calc() {
  float lsqr = leg_len_ * leg_len_;
  float lcub = leg_len_ * leg_len_ * leg_len_;
  //计算当前腿长下的lqrK增益矩阵
  for (uint8_t i = 0; i < 2; ++i) {
    uint8_t j = i * 6;
    T_K_[i][0] =
      (k[j + 0][0] * lcub + k[j + 0][1] * lsqr + k[j + 0][2] * leg_len_ + k[j + 0][3]) * -theta_;
    T_K_[i][1] =
      (k[j + 1][0] * lcub + k[j + 1][1] * lsqr + k[j + 1][2] * leg_len_ + k[j + 1][3]) * -w_theta_;
    T_K_[i][2] =
      (k[j + 2][0] * lcub + k[j + 2][1] * lsqr + k[j + 2][2] * leg_len_ + k[j + 2][3]) * -dist_;
    T_K_[i][3] =
      (k[j + 3][0] * lcub + k[j + 3][1] * lsqr + k[j + 3][2] * leg_len_ + k[j + 3][3]) *
      (target_speed_ - speed_);
    T_K_[i][4] =
      (k[j + 4][0] * lcub + k[j + 4][1] * lsqr + k[j + 4][2] * leg_len_ + k[j + 4][3]) * -phi_;
    T_K_[i][5] =
      (k[j + 5][0] * lcub + k[j + 5][1] * lsqr + k[j + 5][2] * leg_len_ + k[j + 5][3]) * -w_phi_;
  }
  //离地时，仅对髋关节计算theta和theta_dot
  if (F_N_ < 20.0f) {
    for (uint8_t i = 0; i < 6; ++i) {
      T_K_[0][i] = 0.0f;
    };
    T_K_[1][2] = T_K_[1][3] = T_K_[1][4] = T_K_[1][5] = 0.0f;
  }
  //正常情况，计算T和Tp
  for (uint8_t i = 0; i < 2; ++i) {
    T_[i] = T_K_[i][0] + T_K_[i][1] + T_K_[i][2] + T_K_[i][3] + T_K_[i][4] +
      T_K_[i][5];
  }
}